options:
  parameters:
    author: rob
    generate_options: qt_gui
    id: M17_4fsk
    output_language: python
    title: M17_4fsk
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: Unit of deviation in Hz (this * symbol value is symbol deviation in Hz)
    value: '800'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '128'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: This must be at least 512k for PlutoSDR
    value: symbol_rate * interpolation_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rob/m17.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[+1.0,+3.0,-1.0,-3.0]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20.0'
    auto_filter: 'True'
    bandwidth: sample_rate // 2
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '144910000'
    samplerate: sample_rate
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate/2
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', iio_pluto_sink_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
