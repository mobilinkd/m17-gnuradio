options:
  parameters:
    author: rob
    generate_options: qt_gui
    id: M17_bert
    output_language: python
    title: M17_bert
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    comment: Unit of deviation in Hz (this * symbol value is symbol deviation in Hz)
    value: '800'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: symbol_rate * interpolation_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '144910000'
  states: {}
- name: tx_rate
  id: variable
  parameters:
    comment: This must be at least 512k for PlutoSDR
    value: '2000000'
  states: {}
- name: variable_awgn
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise voltage.
    label: AWGN
    start: '0'
    step: '.1'
    stop: '2.0'
    value: '0.0'
  states: {}
- name: variable_clock_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      Symbol clock frequency
      offset in PPM.
    label: Clock
    start: '-250'
    step: '2.5'
    stop: '250'
    value: '0'
  states: {}
- name: variable_frequency_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      Frequency offset expressed
      as a percentage of symbol
      deviation (800Hz).
    label: Frequency
    start: '-100'
    step: '1'
    stop: '100'
    value: '0.0'
  states: {}
- name: variable_qtgui_toggle_button_msg_0
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Fading
    outputmsgname: fading_selector
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: deviation * 2 * 3.141592 / sample_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bert.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1.0 + (variable_clock_offset / 1000000.0)
    freq_offset: (variable_frequency_offset / symbol_rate) * 0.4
    noise_voltage: variable_awgn
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 10.0/sample_rate
    mags: (1,0.99,0.97)
    ntaps: '12'
    seed: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[+1.0,+3.0,-1.0,-3.0]'
  states: {}
- name: osmosdr_sink_1
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    bw0: '25000'
    clock_source0: external
    freq0: tx_freq
    gain0: '14'
    if_gain0: '25'
    sample_rate: tx_rate
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: sample_rate
    type: complex
    ymax: '6'
    ymin: '-6'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    fbw: '0.4'
    interp: 'int((tx_rate * 3)/sample_rate) '
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_selector_0, '0']
- [analog_frequency_modulator_fc_0, '0', channels_selective_fading_model_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_selector_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', rational_resampler_xxx_0, '0']
- [channels_selective_fading_model_0, '0', blocks_selector_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_1, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [variable_qtgui_toggle_button_msg_0, state, blocks_selector_0, iindex]

metadata:
  file_format: 1
